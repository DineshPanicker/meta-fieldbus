FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://rt.cfg"
